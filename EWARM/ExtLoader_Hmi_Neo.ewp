# IAR project ExtLoader_Hmi_Neo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743II ST STM32H743II
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx
  ICCARM.CCIncludePath2: ..\Inc; ..\Driver\STM32Cube_FW_H7_V1.3.2\CMSIS\Device\ST\STM32H7xx\Include; ..\Driver\STM32Cube_FW_H7_V1.3.2\CMSIS\Include; ..\Driver\STM32Cube_FW_H7_V1.3.2\STM32H7xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ExtLoader_Hmi_Neo.srec
  ILINK.IlinkOutputFile: W25Q64_HMI-NEO.out
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkProgramEntryLabel: Init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application/Src
    ../Src/: Dev_Inf.c Loader_Src.c stm32h7xx_hal_msp.c
  group Driver/CMSIS
    ../Src/: system_stm32h7xx.c
  group Driver/STM32H7xx_HAL_Driver
    ../Driver/STM32Cube_FW_H7_V1.3.2/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c
