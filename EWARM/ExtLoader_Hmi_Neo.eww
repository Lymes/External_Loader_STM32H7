<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ExtLoader_Hmi_Neo.ewp</path>
    </project>
    <batchBuild />
</workspace>
